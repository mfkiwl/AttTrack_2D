# Keil uVision project IS203.uvprojx, settings and files
target IS203 (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32H743ZITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.1.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: IS203 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\CORE;..\HALLIB\STM32H7xx_HAL_Driver\Inc;..\ALGORITHM;..\ATTTRACK;..\DRIVER;..\HAL;..\TASK;..\USER
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group USER
    ../USER/: main.c global.c can_protocol.c stm32h7xx_it.c stm32h7xx_hal_msp.c system_stm32h7xx.c
  group TASK
    ../TASK/: scheduler.c fastloop.c tasks.c system.c
  group ALGORITHM
    ../ALGORITHM/: angle_cal.c
  group ATTTRACK
    ../ATTTRACK/: ATProcess.c AttInit.c AttTrack_lib.c kalmanfilter.c DataStruct.c ComFunc.c Calibrate.c
  group HAL
    ../HAL/: hal.c hal_config.c hal_typedef.c
  group DRIVER
    ../DRIVER/: systick.c gpio.c spi.c usart.c fdcan.c timer.c
  group HALLIB
    ../HALLIB/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c
  group CORE
    ../CORE/: cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h core_cm7.h startup_stm32h743xx.s
